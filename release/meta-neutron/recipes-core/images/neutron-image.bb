inherit core-image

IMAGE_INSTALL:append = " neutron-app alsa-utils"
